v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
F {}
E {}
T {iin} -170 -120 0 0 0.4 0.4 {}
T {digout} 4080 -160 0 0 0.4 0.4 {}
T {VCC} 2280 -560 0 0 0.4 0.4 {}
T {VSS} 2250 -20 0 0 0.4 0.4 {}
T {clk} 1650 -320 0 0 0.4 0.4 {}
T {ref} 1650 10 0 0 0.4 0.4 {}
T {in} 2920 -160 0 0 0.4 0.4 {}
T {VDD} 3530 -300 0 0 0.4 0.4 {}
T {VSS} 3450 -30 0 0 0.4 0.4 {}
N 20 -90 20 -60 {lab=#net1}
N -20 -90 -20 -30 {lab=#net2}
N 20 -30 20 0 {lab=#net3}
N 20 -180 20 -150 {lab=#net4}
N 100 -90 140 -90 {lab=#net1}
N 20 -120 20 -90 {lab=#net1}
N 20 -180 270 -180 {lab=#net4}
N 140 -0 270 -0 {lab=#net3}
N 300 -250 720 -250 {lab=#net5}
N -70 -250 240 -250 {lab=#net2}
N -70 -250 -70 -90 {lab=#net2}
N -70 -90 -20 -90 {lab=#net2}
N -20 -150 -20 -90 {lab=#net2}
N 100 -90 100 -30 {lab=#net1}
N 20 -90 100 -90 {lab=#net1}
N 140 -90 140 -60 {lab=#net1}
N 140 -30 140 -0 {lab=#net3}
N 20 0 140 -0 {lab=#net3}
N 140 -90 230 -90 {lab=#net1}
N 270 -90 270 -60 {lab=#net6}
N 230 -90 230 -30 {lab=#net1}
N 270 -30 270 0 {lab=#net3}
N 270 -180 270 -150 {lab=#net4}
N 350 -90 390 -90 {lab=#net6}
N 270 -120 270 -90 {lab=#net6}
N 270 -180 560 -180 {lab=#net4}
N 390 0 560 -0 {lab=#net3}
N 230 -150 230 -90 {lab=#net1}
N 350 -90 350 -30 {lab=#net6}
N 270 -90 350 -90 {lab=#net6}
N 390 -90 390 -60 {lab=#net6}
N 390 -30 390 0 {lab=#net3}
N 270 0 390 0 {lab=#net3}
N 390 -90 520 -90 {lab=#net6}
N 560 -90 560 -60 {lab=#net5}
N 520 -90 520 -30 {lab=#net6}
N 560 -30 560 0 {lab=#net3}
N 560 -180 560 -150 {lab=#net4}
N 640 -90 680 -90 {lab=#net5}
N 560 -120 560 -90 {lab=#net5}
N 520 -150 520 -90 {lab=#net6}
N 640 -90 640 -30 {lab=#net5}
N 560 -90 640 -90 {lab=#net5}
N 680 -90 680 -60 {lab=#net5}
N 680 -30 680 0 {lab=#net3}
N 560 0 680 0 {lab=#net3}
N 680 -90 720 -90 {lab=#net5}
N 720 -250 720 -90 {lab=#net5}
N 720 -90 790 -90 {lab=#net5}
N 680 0 830 0 {lab=#net3}
N 830 -90 830 0 {lab=#net3}
N 780 -210 830 -210 {lab=#net4}
N 270 -210 270 -180 {lab=#net4}
N 830 -130 830 -120 {lab=#net7}
N 780 -250 780 -210 {lab=#net4}
N 270 -210 780 -210 {lab=#net4}
N 1050 -100 1050 0 {lab=#net3}
N 960 -130 1010 -130 {lab=#net7}
N 830 -150 830 -130 {lab=#net7}
N 830 -210 830 -200 {lab=#net4}
N 1050 -170 1050 -160 {lab=#net8}
N 1050 -250 1050 -240 {lab=#net4}
N 1050 -180 1050 -170 {lab=#net8}
N 780 -250 1050 -250 {lab=#net4}
N 960 -0 1050 0 {lab=#net3}
N 1660 -170 1790 -170 {lab=#net8}
N 1660 -250 1790 -250 {lab=#net4}
N 1200 -180 1200 -170 {lab=#net8}
N 1050 -170 1200 -170 {lab=#net8}
N 1350 -180 1350 -170 {lab=#net8}
N 1200 -170 1350 -170 {lab=#net8}
N 1510 -180 1510 -170 {lab=#net8}
N 1350 -170 1510 -170 {lab=#net8}
N 1200 -250 1200 -240 {lab=#net4}
N 1050 -250 1200 -250 {lab=#net4}
N 1660 -180 1660 -170 {lab=#net8}
N 1510 -170 1660 -170 {lab=#net8}
N 1790 -180 1790 -170 {lab=#net8}
N 1350 -250 1350 -240 {lab=#net4}
N 1200 -250 1350 -250 {lab=#net4}
N 1510 -250 1510 -240 {lab=#net4}
N 1350 -250 1510 -250 {lab=#net4}
N 1660 -250 1660 -240 {lab=#net4}
N 1510 -250 1660 -250 {lab=#net4}
N 1790 -250 1790 -240 {lab=#net4}
N 1200 -170 1200 -100 {lab=#net8}
N 1200 -40 1200 0 {lab=#net3}
N 1050 0 1200 0 {lab=#net3}
N 960 -130 960 -90 {lab=#net7}
N 830 -130 960 -130 {lab=#net7}
N 960 -30 960 -0 {lab=#net3}
N 830 0 960 -0 {lab=#net3}
N 2990 -130 2990 -110 {lab=#net9}
N 2990 -80 2990 0 {lab=#net3}
N 2950 -130 2950 -80 {lab=#net10}
N 2990 -270 2990 -190 {lab=#net4}
N 2890 -130 2950 -130 {lab=#net10}
N 2950 -190 2950 -130 {lab=#net10}
N 2990 -130 3120 -130 {lab=#net9}
N 2990 -160 2990 -130 {lab=#net9}
N 3160 -130 3160 -110 {lab=#net11}
N 3160 -80 3160 0 {lab=#net3}
N 3120 -130 3120 -80 {lab=#net9}
N 3160 -270 3160 -190 {lab=#net4}
N 3120 -190 3120 -130 {lab=#net9}
N 3160 -130 3290 -130 {lab=#net11}
N 3160 -160 3160 -130 {lab=#net11}
N 3330 -130 3330 -110 {lab=#net12}
N 3330 -80 3330 0 {lab=#net3}
N 3290 -130 3290 -80 {lab=#net11}
N 3330 -270 3330 -190 {lab=#net4}
N 3290 -190 3290 -130 {lab=#net11}
N 3330 -130 3520 -130 {lab=#net12}
N 3330 -160 3330 -130 {lab=#net12}
N 3560 -80 3560 0 {lab=#net3}
N 3520 -130 3520 -80 {lab=#net12}
N 3560 -270 3560 -190 {lab=#net4}
N 3520 -190 3520 -130 {lab=#net12}
N 3560 -110 3750 -110 {lab=#net13}
N 3560 -160 3560 -110 {lab=#net13}
N 3790 -130 3790 -110 {lab=#net14}
N 3790 -80 3790 0 {lab=#net3}
N 3750 -110 3750 -80 {lab=#net13}
N 3790 -270 3790 -190 {lab=#net4}
N 3750 -190 3750 -110 {lab=#net13}
N 3790 -130 3980 -130 {lab=#net14}
N 3790 -160 3790 -130 {lab=#net14}
N 4020 -130 4020 -110 {lab=#net15}
N 4020 -80 4020 0 {lab=#net3}
N 3980 -130 3980 -80 {lab=#net14}
N 4020 -270 4020 -190 {lab=#net4}
N 3980 -190 3980 -130 {lab=#net14}
N 4020 -130 4150 -130 {lab=#net15}
N 4020 -160 4020 -130 {lab=#net15}
N 3790 0 4020 0 {lab=#net3}
N 3560 0 3790 0 {lab=#net3}
N 3330 0 3560 0 {lab=#net3}
N 3160 0 3330 0 {lab=#net3}
N 2990 0 3160 0 {lab=#net3}
N 2990 -270 3160 -270 {lab=#net4}
N 3330 -270 3560 -270 {lab=#net4}
N 3790 -270 4020 -270 {lab=#net4}
N 3560 -270 3790 -270 {lab=#net4}
N 3160 -270 3330 -270 {lab=#net4}
N -170 -90 -70 -90 {lab=#net2}
N 2090 -450 2180 -450 {lab=#net16}
N 2140 -480 2220 -480 {lab=#net4}
N 2040 -480 2040 -450 {lab=#net4}
N 2220 -480 2220 -450 {lab=#net4}
N 2140 -540 2140 -480 {lab=#net4}
N 2040 -480 2140 -480 {lab=#net4}
N 2420 -470 2420 -440 {lab=#net4}
N 2520 -470 2600 -470 {lab=#net4}
N 2600 -470 2600 -440 {lab=#net4}
N 2140 -540 2520 -540 {lab=#net4}
N 2520 -540 2520 -470 {lab=#net4}
N 2500 -470 2520 -470 {lab=#net4}
N 2040 -400 2040 -360 {lab=#net17}
N 2220 -380 2220 -360 {lab=#net10}
N 2160 -330 2220 -330 {lab=#net3}
N 2160 -330 2160 -210 {lab=#net3}
N 2040 -330 2160 -330 {lab=#net3}
N 2130 -210 2160 -210 {lab=#net3}
N 2160 -210 2160 -180 {lab=#net3}
N 2130 -180 2160 -180 {lab=#net3}
N 2130 -180 2130 -90 {lab=#net3}
N 2090 -90 2130 -90 {lab=#net3}
N 2190 -90 2220 -90 {lab=#net3}
N 2220 -90 2220 -0 {lab=#net3}
N 2040 -90 2040 -0 {lab=#net3}
N 2130 -90 2130 -0 {lab=#net3}
N 2040 0 2130 -0 {lab=#net3}
N 2130 0 2220 -0 {lab=#net3}
N 2040 -120 2090 -120 {lab=#net3}
N 2090 -120 2090 -90 {lab=#net3}
N 2040 -90 2090 -90 {lab=#net3}
N 2190 -120 2220 -120 {lab=#net3}
N 2190 -120 2190 -90 {lab=#net3}
N 2130 -90 2190 -90 {lab=#net3}
N 2260 -170 2260 -90 {lab=#net8}
N 2340 -310 2380 -310 {lab=#net17}
N 2340 -400 2340 -310 {lab=#net17}
N 2040 -400 2340 -400 {lab=#net17}
N 2040 -420 2040 -400 {lab=#net17}
N 2220 -380 2310 -380 {lab=#net10}
N 2220 -420 2220 -380 {lab=#net10}
N 2310 -220 2560 -220 {lab=#net10}
N 2310 -380 2310 -220 {lab=#net10}
N 2420 -410 2420 -340 {lab=#net18}
N 2600 -410 2600 -250 {lab=#net19}
N 2600 -220 2640 -220 {lab=#net4}
N 2640 -300 2640 -220 {lab=#net4}
N 2500 -300 2640 -300 {lab=#net4}
N 2500 -310 2500 -300 {lab=#net4}
N 2420 -470 2500 -470 {lab=#net4}
N 2420 -310 2500 -310 {lab=#net4}
N 2500 -470 2500 -310 {lab=#net4}
N 1790 -170 2260 -170 {lab=#net8}
N 2260 -330 2260 -170 {lab=#net8}
N 1790 -540 1790 -250 {lab=#net4}
N 1860 -540 2140 -540 {lab=#net4}
N 1860 -0 2040 -0 {lab=#net3}
N 2040 -300 2040 -270 {lab=#net20}
N 2130 -270 2220 -270 {lab=#net20}
N 2220 -300 2220 -270 {lab=#net20}
N 2130 -270 2130 -240 {lab=#net20}
N 2040 -270 2130 -270 {lab=#net20}
N 2090 -250 2090 -210 {lab=#net16}
N 2080 -450 2090 -450 {lab=#net16}
N 1900 -250 2090 -250 {lab=#net16}
N 2090 -450 2090 -250 {lab=#net16}
N 2350 -90 2350 -0 {lab=#net3}
N 2520 -90 2520 -0 {lab=#net3}
N 2630 -90 2630 0 {lab=#net3}
N 2780 -90 2780 -0 {lab=#net3}
N 2350 -0 2520 0 {lab=#net3}
N 2520 -0 2630 0 {lab=#net3}
N 2630 0 2780 -0 {lab=#net3}
N 2220 0 2350 -0 {lab=#net3}
N 2350 -160 2350 -120 {lab=#net21}
N 2420 -160 2520 -160 {lab=#net21}
N 2520 -160 2520 -120 {lab=#net21}
N 2630 -160 2630 -120 {lab=#net10}
N 2710 -160 2780 -160 {lab=#net10}
N 2780 -160 2780 -120 {lab=#net10}
N 2310 -90 2310 80 {lab=#net22}
N 2310 80 2820 80 {lab=#net22}
N 2820 -90 2820 80 {lab=#net22}
N 2420 -190 2420 -160 {lab=#net21}
N 2350 -160 2420 -160 {lab=#net21}
N 2420 -190 2580 -190 {lab=#net21}
N 2580 -180 2580 -90 {lab=#net21}
N 2580 -90 2590 -90 {lab=#net21}
N 2420 -250 2420 -190 {lab=#net21}
N 1900 -290 1900 -250 {lab=#net16}
N 1820 -290 1900 -290 {lab=#net16}
N 2000 -330 2000 40 {lab=#net23}
N 1650 -290 1820 -290 {lab=#net16}
N 1820 -440 1820 -290 {lab=#net16}
N 1860 -400 1860 -380 {lab=#net22}
N 1860 -540 1860 -440 {lab=#net4}
N 1790 -540 1860 -540 {lab=#net4}
N 1860 -350 1860 -0 {lab=#net3}
N 1200 0 1860 -0 {lab=#net3}
N 1860 -400 1920 -400 {lab=#net22}
N 1860 -410 1860 -400 {lab=#net22}
N 1920 -400 1920 80 {lab=#net22}
N 1920 80 2310 80 {lab=#net22}
N 1650 40 2000 40 {lab=#net23}
N 2560 -170 2560 -90 {lab=#net10}
N 2560 -170 2710 -170 {lab=#net10}
N 2710 -170 2710 -160 {lab=#net10}
N 2630 -160 2710 -160 {lab=#net10}
N 2890 -170 2890 -130 {lab=#net10}
N 2870 -0 2990 -0 {lab=#net3}
N 2870 -30 2870 0 {lab=#net3}
N 2780 0 2870 -0 {lab=#net3}
N 2520 -540 2990 -540 {lab=#net4}
N 2990 -540 2990 -270 {lab=#net4}
N 2710 -170 2890 -170 {lab=#net10}
N 2600 -190 2710 -190 {lab=#net10}
N 2710 -190 2710 -170 {lab=#net10}
N 2560 -220 2560 -170 {lab=#net10}
N 2560 -380 2560 -220 {lab=#net10}
N 2460 -380 2560 -380 {lab=#net10}
N 2460 -440 2460 -380 {lab=#net10}
N 2580 -180 2870 -180 {lab=#net21}
N 2580 -190 2580 -180 {lab=#net21}
N 2870 -180 2870 -90 {lab=#net21}
N 2530 -440 2560 -440 {lab=#net21}
N 2530 -440 2530 -250 {lab=#net21}
N 2420 -250 2530 -250 {lab=#net21}
N 2420 -280 2420 -250 {lab=#net21}
C {sg13g2_pr/sg13_lv_rf_pmos.sym} 0 -150 0 0 {name=M1
l=0.13u
w=14u
ng=2
m=1
rfmode=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_rf_nmos.sym} 0 -30 0 0 {name=M2
l=0.13u
w=14.0u
ng=2
m=1
rfmode=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_rf_pmos.sym} 2970 -190 0 0 {name=M3
l=0.13u
w=1.65u
ng=1
m=1
rfmode=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_rf_nmos.sym} 2970 -80 0 0 {name=M4
l=0.13u
w=0.825u
ng=1
m=1
rfmode=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_rf_nmos.sym} 810 -90 0 0 {name=M9
l=0.13u
w=21u
ng=3
m=1
rfmode=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/rppd.sym} 830 -170 0 0 {name=R1
w=0.5e-6
l=2.65e-6
model=rppd
body=sub!
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rppd.sym} 270 -250 3 0 {name=R2
w=0.5e-6
l=20.16e-6
model=rppd
body=sub!
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/sg13_lv_rf_nmos.sym} 120 -30 0 0 {name=M10
l=0.13u
w=4.6u
ng=1
m=1
rfmode=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_rf_pmos.sym} 250 -150 0 0 {name=M5
l=0.13u
w=14u
ng=2
m=1
rfmode=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_rf_nmos.sym} 250 -30 0 0 {name=M6
l=0.13u
w=14.0u
ng=2
m=1
rfmode=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_rf_nmos.sym} 370 -30 0 0 {name=M7
l=0.13u
w=4.6u
ng=1
m=1
rfmode=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_rf_pmos.sym} 540 -150 0 0 {name=M8
l=0.13u
w=14u
ng=2
m=1
rfmode=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_rf_nmos.sym} 540 -30 0 0 {name=M11
l=0.13u
w=14.0u
ng=2
m=1
rfmode=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_rf_nmos.sym} 660 -30 0 0 {name=M12
l=0.13u
w=4.6u
ng=1
m=1
rfmode=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_rf_nmos.sym} 1030 -130 0 0 {name=M13
l=0.13u
w=50.0u
ng=10
m=1
rfmode=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/rppd.sym} 1050 -210 0 0 {name=R3
w=0.5e-6
l=2.65e-6
model=rppd
body=sub!
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rppd.sym} 1200 -210 0 0 {name=R4
w=0.5e-6
l=2.65e-6
model=rppd
body=sub!
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rppd.sym} 1350 -210 0 0 {name=R5
w=0.5e-6
l=2.65e-6
model=rppd
body=sub!
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rppd.sym} 1510 -210 0 0 {name=R6
w=0.5e-6
l=2.65e-6
model=rppd
body=sub!
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rppd.sym} 1660 -210 0 0 {name=R7
w=0.5e-6
l=2.65e-6
model=rppd
body=sub!
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/rppd.sym} 1790 -210 0 0 {name=R8
w=0.5e-6
l=2.65e-6
model=rppd
body=sub!
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/cap_cmim.sym} 960 -60 0 0 {name=C1
model=cap_cmim
w=8.1e-6
l=8.1e-6
m=1
spiceprefix=X}
C {sg13g2_pr/cap_cmim.sym} 1200 -70 0 0 {name=C2
model=cap_cmim
w=14.1e-6
l=14.1e-6
m=1
spiceprefix=X}
C {sg13g2_pr/sg13_lv_rf_pmos.sym} 2200 -450 0 0 {name=M14
l=0.13u
w=3.0u
ng=1
m=1
rfmode=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_rf_nmos.sym} 2020 -330 0 0 {name=M15
l=0.13u
w=4.0u
ng=1
m=1
rfmode=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_rf_pmos.sym} 3140 -190 0 0 {name=M16
l=0.13u
w=1.65u
ng=1
m=1
rfmode=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_rf_nmos.sym} 3140 -80 0 0 {name=M17
l=0.13u
w=0.825u
ng=1
m=1
rfmode=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_rf_pmos.sym} 3310 -190 0 0 {name=M18
l=0.13u
w=1.65u
ng=1
m=1
rfmode=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_rf_nmos.sym} 3310 -80 0 0 {name=M19
l=0.13u
w=0.825u
ng=1
m=1
rfmode=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_rf_pmos.sym} 3540 -190 0 0 {name=M20
l=0.13u
w=1.65u
ng=1
m=1
rfmode=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_rf_nmos.sym} 3540 -80 0 0 {name=M21
l=0.13u
w=0.825u
ng=1
m=1
rfmode=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_rf_pmos.sym} 3770 -190 0 0 {name=M22
l=0.13u
w=1.65u
ng=1
m=1
rfmode=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_rf_nmos.sym} 3770 -80 0 0 {name=M23
l=0.13u
w=0.825u
ng=1
m=1
rfmode=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_rf_pmos.sym} 4000 -190 0 0 {name=M24
l=0.13u
w=1.65u
ng=1
m=1
rfmode=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_rf_nmos.sym} 4000 -80 0 0 {name=M25
l=0.13u
w=0.825u
ng=1
m=1
rfmode=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_rf_pmos.sym} 2060 -450 0 1 {name=M26
l=0.13u
w=3.0u
ng=1
m=1
rfmode=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_rf_pmos.sym} 2580 -440 0 0 {name=M27
l=0.13u
w=12.0u
ng=2
m=1
rfmode=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_rf_pmos.sym} 2440 -440 0 1 {name=M28
l=0.13u
w=12.0u
ng=2
m=1
rfmode=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_rf_nmos.sym} 2240 -330 0 1 {name=M29
l=0.13u
w=4.0u
ng=1
m=1
rfmode=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_rf_nmos.sym} 2110 -210 0 0 {name=M30
l=0.13u
w=1.0u
ng=1
m=1
rfmode=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_rf_nmos.sym} 2020 -90 0 0 {name=M31
l=0.13u
w=4.0u
ng=1
m=1
rfmode=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_rf_nmos.sym} 2240 -90 0 1 {name=M32
l=0.13u
w=4.0u
ng=1
m=1
rfmode=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_rf_pmos.sym} 2400 -310 0 0 {name=M33
l=0.13u
w=12.0u
ng=2
m=1
rfmode=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_rf_pmos.sym} 2580 -220 0 0 {name=M34
l=0.13u
w=12.0u
ng=2
m=1
rfmode=1
model=sg13_lv_pmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_rf_nmos.sym} 2330 -90 0 0 {name=M35
l=0.13u
w=1.0u
ng=1
m=1
rfmode=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_rf_nmos.sym} 2610 -90 0 0 {name=M36
l=0.13u
w=4.0u
ng=1
m=1
rfmode=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_rf_nmos.sym} 2540 -90 0 1 {name=M37
l=0.13u
w=4.0u
ng=1
m=1
rfmode=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_rf_nmos.sym} 2800 -90 0 1 {name=M38
l=0.13u
w=1.0u
ng=1
m=1
rfmode=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/rppd.sym} 2870 -60 2 0 {name=R10
w=0.5e-6
l=20.16e-6
model=rppd
body=sub!
spiceprefix=X
b=0
m=1
}
C {sg13g2_pr/sg13_lv_rf_nmos.sym} 1840 -350 0 0 {name=M39
l=0.13u
w=0.5u
ng=1
m=1
rfmode=1
model=sg13_lv_nmos
spiceprefix=X
}
C {sg13g2_pr/sg13_lv_rf_pmos.sym} 1840 -440 0 0 {name=M40
l=0.13u
w=1.0u
ng=1
m=1
rfmode=1
model=sg13_lv_pmos
spiceprefix=X
}
